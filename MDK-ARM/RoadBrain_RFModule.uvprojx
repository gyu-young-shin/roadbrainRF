# Keil uVision project RoadBrain_RFModule.uvprojx, settings and files
target RoadBrain_RFModule (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RoadBrain_2nd_V3_3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Sources;../Sources/W5100S;../Sources/Internet/DHCP;../Sources/Internet/DNS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Sources
    ../Sources/: Buzzer.c Debug.c FlashRom.c MyTimer.c RS485.c W5100S_Proc.c W5100SRelFunctions.c Segment.c Wifi.c Repeater.c RS232C.c Modbus.c Test.c
  group W5100S Lib
    ../Sources/: socket.c wizchip_conf.c
    ../Sources/W5100S/: w5100s.c
    ../Sources/Internet/DHCP/: dhcp.c
    ../Sources/Internet/DNS/: dns.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 5.4.0
